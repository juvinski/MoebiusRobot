# Keil uVision project project.uvprojx, settings and files
target STM32_ROS (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x0000C000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: rt-thread +hex
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F103xE, USE_HAL_DRIVER
  c include: .;..\..\..\include;applications;.;board;board\CubeMX_Config\Inc;board\ports;..\libraries\HAL_Drivers;..\libraries\HAL_Drivers\config;.;packages\mpu6xxx-latest\inc;packages\rosserial-melodic-latest;packages\rosserial-melodic-latest\port;packages\rosserial-melodic-latest\src;..\..\..\libcpu\arm\common;..\..\..\libcpu\arm\cortex-m3;..\..\..\components\cplusplus;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\drivers\spi;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\drivers\sensors;..\..\..\components\drivers\include;..\..\..\components\finsh;..\..\..\components\libc\compilers\common;..\..\..\components\utilities\ulog;..\libraries\STM32F1xx_HAL\CMSIS\Device\ST\STM32F1xx\Include;..\libraries\STM32F1xx_HAL\STM32F1xx_HAL_Driver\Inc;..\libraries\STM32F1xx_HAL\CMSIS\Include;.\applications\iic_wire;.\applications\filter;.\applications\moebius;..\..\..\components\drivers\misc;.\packages\mpu6xxx-latest\src;.\packages\mpu6xxx-latest\inc;.\packages\mpu6xxx-latest\samples;.\applications\imu_dev;.\packages\bmi160_bmx160-latest;.\packages\bmi160_bmx160-latest\libraries;.\applications\ros;.\packages\rosserial-kinetic-latest;.\packages\rosserial-kinetic-latest\port;.\packages\rosserial-kinetic-latest\src
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  scatter file: .\board\linker_scripts\link.sct
  group Application
    ./applications/: main.cpp config.h rt-thread.lib
    ./: rtconfig.h
  group Drivers
    ../libraries/HAL_Drivers/: drv_gpio.c drv_usart.c drv_pwm.c drv_adc.c drv_common.c drv_pulse_encoder.c drv_soft_i2c.c
  group CPlusPlus
    ../../../components/cplusplus/: Mutex.cpp Semaphore.cpp Thread.cpp crt.cpp crt_init.c
  group Filter
    ./applications/filter/: Kinematics.cpp
  group moebius
    ./applications/moebius/: battery.cpp car.cpp motors.cpp datascope.cpp
    ./applications/imu_dev/: imu_dev.cpp
